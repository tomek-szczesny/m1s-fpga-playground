# Repository tomek-szczesny/m1s-fpga-playground

File README.md:

# m1s-fpga-playground

This is an add-on board with FPGA for ODROID M1S.

It contains Lattice ICE40HX4K-TQ144 FPGA and a few peripherals to interact with.

More details available on ODROID forum:

[mctom's FPGA playground for ODROID M1S - ODROID](https://forum.odroid.com/viewtopic.php?f=217&t=47573)

## KiCad design kicad/m1s-fpga-playground/m1s-fpga-playground.kicad_pcb

Board: 4 copper layers, 90.0 x 65.0 mm, 188 parts (2 on the bottom side), 185 nets.

Parts:
C101, C102, C103, C104, C105, C106, C107, C108, C110, C112, C113, C114, C115, C116, C118, C119, C120, C121, C122, C123, C124, C127, C128, C129, C130, C305, C501, C601, C603, C604, C605, C606, C607, C608, C609, C611, C613, C614, C707: 100n; C_0603_1608Metric
C109, C111, C306, C307, C308: 10u; C_0603_1608Metric
C125, C126: 10n; C_0603_1608Metric
C301, C303, C615, C616: 30p; C_0603_1608Metric
C302, C304: 10p; C_0603_1608Metric
C602, C610, C612: 4u7; C_0603_1608Metric
C702: 10n 16V; C_0603_1608Metric
C704, C705, C708: 22u 35V; C_1206_3216Metric
C706: 6n8; C_0603_1608Metric
D101: BAT54S; SOT-23
D102: Green; LED_0603_1608Metric
D108: BAT54A; SOT-23
D217, D218, D219, D220, D221, D222, D223: G; LED_0603_1608Metric
FB301, FB302, FB601, FB602: FerriteBead_Small; C_0603_1608Metric
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3_DIN965_Pad
J1: Conn_02x20_Odd_Even; PinSocket_2x20_P2.54mm_Vertical
J2: Conn_02x07_Odd_Even; PinSocket_2x07_P2.54mm_Vertical
J102: Pin Header; PinHeader_1x04_P2.54mm_Vertical
J301: ICD15S13E4GX00LF
J302: CUI_SJ1-3533NG; Jack_3.5mm_CUI_SJ1-3533NG_Horizontal
J501: 10029449-101RLF; HDMI_A_Amphenol_10029449-x01xLF_Horizontal
J702: CUI PJ102; BarrelJack_CUI_PJ-102AH_Horizontal
J703: 5.08mm; TerminalBlock_Phoenix_MKDS-3-2-5.08_1x02_P5.08mm_Horizontal
L701: SRN8040-100M; L_Bourns-SRN8040_8x8.15mm
LOGO101: Logo_Open_Hardware_Small; OSHW-Logo_7.5x8mm_SilkScreen
Q501, Q502, Q503: 2N7002; SOT-23
Q701: PMT21EN; SOT-223
R101: 22R; R_0603_1608Metric
R102, R105, R107, R108, R109, R332, R333, R604, R605, R606: 10k; R_0603_1608Metric
R103, R104: 100R; R_0603_1608Metric
R110, R217, R218, R219, R220, R221, R222, R223: 2k2; R_0603_1608Metric
R301, R302, R303, R310, R311, R312, R319, R320, R321: 1k 0.1%; R_0603_1608Metric
R304, R305, R306, R313, R314, R315, R322, R323, R324: 2k 0.1%; R_0603_1608Metric
R307, R308, R316, R317, R318, R325, R326: 16k 0.1%; R_0603_1608Metric
R309, R327: 120R; R_0603_1608Metric
R328, R329, R330, R331: 47k; R_0603_1608Metric
R501, R502, R503, R504: NM; R_0603_1608Metric
R505, R506, R507, R508, R509, R510, R511, R512: 0; R_0603_1608Metric
R513, R515, R517: 4k7; R_0603_1608Metric
R514, R516, R518: 1k5; R_0603_1608Metric
R519: 51R; R_0603_1608Metric
R520, R602: 1k; R_0603_1608Metric
R521, R701, R706: 100k; R_0603_1608Metric
R601: 12k; R_0603_1608Metric
R603: 2k; R_0603_1608Metric
R703: 6k8; R_0603_1608Metric
R704: 33k; R_0603_1608Metric
R705: 7k5; R_0603_1608Metric
SW101, SW102, SW103, SW104, SW105: KMR2; SW_Push_1P1T_NO_CK_KMR2
U101: W25Q16JLSSIG; SOIC-8_5.23x5.23mm_P1.27mm
U102: ICE40HX4K-TQ144; TQFP-144_20x20mm_P0.5mm
U103: TLV71312PDBV; SOT-23-5
U106: AS4C32M8SA; TSOP-II-54_22.2x10.16mm_P0.8mm
U301: OPA1602; SO-8_3.9x4.9mm_P1.27mm
U601: FT2232HL; LQFP-64_10x10mm_P0.5mm
U603: 93LCxxC; SO-8_3.9x4.9mm_P1.27mm
U701: AP6503; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.62x3.51mm
X101: ECS-2520MV-xxx-xx; Oscillator_SMD_ECS_2520MV-xxx-xx-4Pin_2.5x2.0mm
Y601: ABM3B-12; Crystal_SMD_Abracon_ABM3B-4Pin_5.0x3.2mm

Connections:
+1V2: C104.1, C105.1, C106.1, C107.1, C116.1, R103.2, R104.2, U102.27 (VCC), U102.40 (VCC), U102.92 (VCC), U102.111 (VCC), U103.5 (OUT)
+3V3: C101.1, C102.1, C103.1, C112.1, C113.1, C114.1, C115.1, C118.1, C119.1, C120.1, C121.1, C122.1, C123.1, C124.1, C127.1, C128.1, C129.1, C130.1, C601.1, C603.1, C604.1, C605.1, C606.1, C614.1, D101.1, FB301.2, FB601.1, FB602.1, J1.1, J1.17, J2.2, J102.2, Q501.1 (G), Q502.1 (G), Q503.1 (G), R102.1, R107.1, R108.1, R109.1, R110.1, R513.2, R515.2, R517.2, R602.2, R604.2, R605.2, R606.2, U101.8 (VCC), U102.6 (VCCIO_3), U102.30 (VCCIO_3), U102.46 (VCCIO_2), U102.57 (VCCIO_2), U102.72 (VCC_SPI), U102.89 (VCCIO_1), U102.100 (VCCIO_1), U102.123 (VCCIO_0), U102.131 (VCCIO_0), U103.1 (IN), U103.3 (EN), U106.1 (VDD), U106.3 (VDDQ), U106.9 (VDDQ), U106.14 (VDD), U106.27 (VDD), U106.43 (VDDQ), U106.49 (VDDQ), U601.20 (VCCIO), U601.31 (VCCIO), U601.42 (VCCIO), U601.50 (VREGIN), U601.56 (VCCIO), U603.6 (ORG), U603.8 (VCC), X101.1 (Tri-State), X101.4 (VDD)
+5V: C501.1, J1.2, J1.4, R514.2, R516.2, R518.2, R519.2
+5VP: J2.1, Q701.2 (D), Q701.4 (D)
/1: U102.1 (IOL_2A), U106.20 (BA0)
/2: U102.2 (IOL_2B), U106.21 (BA1)
/3: U102.3 (IOL_3A), U106.22 (A10/AP)
/4: U102.4 (IOL_3B), U106.23 (A0)
/7: U102.7 (IOL_4A), U106.24 (A1)
/8: U102.8 (IOL_4B), U106.25 (A2)
/9: U102.9 (IOL_5A), U106.26 (A3)
/10: U102.10 (IOL_5B), U106.39 (DQM)
/11: U102.11 (IOL_8A), U106.38 (CLK)
/12: R105.2, U102.12 (IOL_8B), U106.37 (CKE)
/15: U102.15 (IOL_10A), U106.36 (A12)
/16: U102.16 (IOL_10B), U106.35 (A11)
/17: U102.17 (IOL_12A), U106.34 (A9)
/18: U102.18 (IOL_12B), U106.33 (A8)
/19: U102.19 (IOL_13A), U106.32 (A7)
/20: U102.20 (IOL_13B_GBIN7), U106.31 (A6)
/21: U102.21 (IOL_14A_GBIN6), U106.30 (A5)
/22: U102.22 (IOL_14B), U106.29 (A4)
/23: R327.2, U102.23 (IOL_17A)
/24: R309.2, U102.24 (IOL_17B)
/25: R325.2, R326.2, U102.25 (IOL_18A)
/26: R323.2, U102.26 (IOL_18B)
/28: R322.2, U102.28 (IOL_23A)
/29: R321.2, U102.29 (IOL_23B)
/31: R319.2, R320.2, U102.31 (IOL_24A)
/32: R318.2, U102.32 (IOL_24B)
/33: R316.2, R317.2, U102.33 (IOL_25A)
/34: R314.2, U102.34 (IOL_25B)
/37: R305.2, U102.37 (IOB_56)
/38: R304.2, U102.38 (IOB_57)
/39: R303.2, U102.39 (IOB_61)
/41: R301.2, R302.2, U102.41 (IOB_63)
/42: R312.2, U102.42 (IOB_64)
/43: R313.2, U102.43 (IOB_71)
/44: R310.2, R311.2, U102.44 (IOB_72)
/45: R307.2, R308.2, U102.45 (IOB_73)
/47: J1.35, U102.47 (IOB_79)
/48: J1.36, U102.48 (IOB_80)
/49: J1.33, U102.49 (IOB_81_GBIN5)
/52: J1.22, U102.52 (IOB_82_GBIN4)
/55: J1.32, U102.55 (IOB_91)
/56: J1.26, U102.56 (IOB_94)
/60: J1.12, U102.60 (IOB_95)
/61: J1.10, U102.61 (IOB_96)
/62: J1.8, U102.62 (IOB_102)
/63: C125.1, SW103.2, U102.63 (IOB_103_CBSEL0)
/64: C126.1, SW102.2, U102.64 (IOB_104_CBSEL1)
/73: J1.11, U102.73 (IOR_109)
/74: J1.13, U102.74 (IOR_110)
/75: J2.12, U102.75 (IOR_111)
/76: J2.11, U102.76 (IOR_112)
/78: D217.2 (A), U102.78 (IOR_114)
/79: D218.2 (A), U102.79 (IOR_115)
/80: D219.2 (A), U102.80 (IOR_116)
/81: D220.2 (A), U102.81 (IOR_117)
/82: D221.2 (A), U102.82 (IOR_118)
/83: D222.2 (A), U102.83 (IOR_119)
/84: D223.2 (A), U102.84 (IOR_120)
/85: U102.85 (IOR_128), U601.33 (ACBUS6)
/87: U102.87 (IOR_136), U601.34 (ACBUS7)
/88: U102.88 (IOR_137), U601.36 (~SUSPEND)
/90: U102.90 (IOR_138), U601.30 (ACBUS4)
/91: U102.91 (IOR_139), U601.29 (ACBUS3)
/93: U102.93 (IOR_140_GBIN3), U601.28 (ACBUS2)
/94: U102.94 (IOR_141_GBIN2), U601.32 (ACBUS5)
/95: U102.95 (IOR_144), U601.27 (ACBUS1)
/96: U102.96 (IOR_146), U601.26 (ACBUS0)
/97: U102.97 (IOR_147), U601.24 (ADBUS7)
/98: U102.98 (IOR_148), U601.23 (ADBUS6)
/99: U102.99 (IOR_152), U601.22 (ADBUS5)
/101: U102.101 (IOR_160), U601.21 (ADBUS4)
/102: U102.102 (IOR_161), U601.19 (ADBUS3)
/104: U102.104 (IOR_164), U601.18 (ADBUS2)
/105: U102.105 (IOR_165), U601.17 (ADBUS1)
/106: U102.106 (IOR_166), U601.16 (ADBUS0)
/107: U102.107 (IOR_167), U601.60 (~PWREN)
/110: R512.1, U102.110 (IOT_168)
/112: R511.1, U102.112 (IOT_169)
/113: R510.1, U102.113 (IOT_170)
/114: R509.1, U102.114 (IOT_171)
/115: R508.1, U102.115 (IOT_172)
/116: R507.1, U102.116 (IOT_173)
/117: R520.2, U102.117 (IOT_174)
/118: Q501.2 (S), R513.1, U102.118 (IOT_177)
/119: Q503.2 (S), R517.1, U102.119 (IOT_178)
/120: Q502.2 (S), R515.1, U102.120 (IOT_179)
/121: J102.4, U102.121 (IOT_181)
/122: R506.1, U102.122 (IOT_190)
/124: R505.1, U102.124 (IOT_191)
/125: J102.3, U102.125 (IOT_192)
/128: U102.128 (IOT_197_GBIN1), U106.53 (DQ7)
/129: R101.1, U102.129 (IOT_198_GBIN0)
/130: U102.130 (IOT_206), U106.50 (DQ6)
/134: U102.134 (IOT_212), U106.47 (DQ5)
/135: U102.135 (IOT_213), U106.44 (DQ4)
/136: U102.136 (IOT_214), U106.2 (DQ0)
/137: U102.137 (IOT_215), U106.5 (DQ1)
/138: U102.138 (IOT_216), U106.8 (DQ2)
/139: U102.139 (IOT_217), U106.11 (DQ3)
/141: U102.141 (IOT_219), U106.16 (~WE)
/142: U102.142 (IOT_220), U106.17 (~CAS)
/143: U102.143 (IOT_221), U106.18 (~RAS)
/144: U102.144 (IOT_222), U106.19 (~CS)
/HDMI Output/CK+: J501.10 (CK+), R504.1, R511.2
/HDMI Output/CK-: J501.12 (CK-), R504.2, R512.2
/HDMI Output/D0+: J501.7 (D0+), R503.1, R509.2
/HDMI Output/D0-: J501.9 (D0-), R503.2, R510.2
/HDMI Output/D1+: J501.4 (D1+), R502.1, R507.2
/HDMI Output/D1-: J501.6 (D1-), R502.2, R508.2
/HDMI Output/D2+: J501.1 (D2+), R501.1, R505.2
/HDMI Output/D2-: J501.3 (D2-), R501.2, R506.2
/PWRBTN_H: J2.9, SW105.2
/RESET_H: J2.10, SW104.2
/USB-D+: J2.5, U601.8 (DP)
/USB-D-: J2.3, U601.7 (DM)
/USB/USB_Vcore: C602.1, C607.1, C608.1, C609.1, U601.12 (VCORE), U601.37 (VCORE), U601.49 (VREGOUT), U601.64 (VCORE)
/USB/~RESET: R602.1, U601.14 (~RESET)
/VGA - Audio/B: J301.3, R319.1, R320.1, R321.1, R322.1, R324.1, R325.1, R326.1, R329.2
/VGA - Audio/G: J301.2, R310.1, R311.1, R312.1, R313.1, R315.1, R316.1, R317.1, R318.1
/VGA - Audio/HSync_c: J301.13, R309.1
/VGA - Audio/R: J301.1, R301.1, R302.1, R303.1, R304.1, R306.1, R307.1, R308.1, R330.2
/VGA - Audio/VSync_c: J301.14, R327.1
/iCE40-CDONE: D102.2 (A), R110.2, U102.65 (CDONE)
/iCE40-CRESET: D108.3, R109.2, U102.66 (~CRESET)
/iCE40-SCK: J1.23, R108.2, U101.6 (CLK), U102.70 (IOB_107_SCK)
/iCE40-SDI: J1.21, U101.2 (DO(IO1)), U102.68 (IOB_106_SDI)
/iCE40-SDO: J1.19, U101.5 (DI(IO0)), U102.67 (IOB_105_SDO)
/iCE40-SS: J1.24, R107.2, U101.1 (~CS), U102.71 (IOB_108_SS)
/~FPGA_RST: D108.2, J2.14
GND: C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C107.2, C112.2, C113.2, C114.2, C115.2, C116.2, C118.2, C119.2, C120.2, C121.2, C122.2, C123.2, C124.2, C125.2, C126.2, C127.2, C128.2, C129.2, C130.2, C501.2, C601.2, C602.2, C603.2, C604.2, C605.2, C606.2, C607.2, C608.2, C609.2, C610.2, C611.2, C612.2, C613.2, C614.2, C615.2, C616.2, C704.2, C705.2, C707.2, C708.2, D102.1 (K), FB302.2, H1.1, H2.1, H3.1, H4.1, J1.6, J1.9, J1.14, J1.20, J1.25, J1.30, J1.34, J1.39, J2.7, J102.1, J301.0, J301.5, J301.6, J301.7, J301.8, J301.10, J501.2 (D2S), J501.5 (D1S), J501.8 (D0S), J501.11 (CKS), J501.17 (GND), J501.SH, J702.2, J702.3, J703.2, R105.1, R217.2, R218.2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
GND1: C301.2, C303.2, C305.2, C306.2, FB302.1, J302.S, R332.1, R333.1, U301.4 (V-)
unnamed: C302.2, R328.2, R329.1
unnamed: C304.2, R330.1, R331.2
unnamed: C307.2, J302.T, R332.2
unnamed: C308.2, J302.R, R333.2
unnamed: C706.2, R703.2
unnamed: D108.1, SW101.2
unnamed: D217.1 (K), R217.1
unnamed: D218.1 (K), R218.1
unnamed: D219.1 (K), R219.1
unnamed: D220.1 (K), R220.1
unnamed: D221.1 (K), R221.1
unnamed: D222.1 (K), R222.1
unnamed: D223.1 (K), R223.1
unnamed: J501.18 (+5V), R519.1
unnamed: J501.13 (CEC), Q501.3 (D), R514.1
unnamed: J501.19 (HPD), R520.1, R521.1
unnamed: J501.15 (SCL), Q502.3 (D), R516.1
unnamed: J501.16 (SDA), Q503.3 (D), R518.1
unnamed: C704.1, J702.1, J703.1, Q701.1 (G), R701.2, R706.2, U701.2 (IN)
unnamed: C705.1, C708.1, L701.2, Q701.3 (S), R701.1, R704.2
unnamed: R305.1, R306.2
unnamed: R314.1, R315.2
unnamed: R323.1, R324.2
unnamed: R102.2, U101.3 (IO2), U101.7 (IO3)
unnamed: C108.2, C109.2, U102.53 (GNDPLL0)
unnamed: C110.2, C111.2, U102.127 (GNDPLL1)
unnamed: C108.1, C109.1, R103.1, U102.54 (VCCPLL0)
unnamed: C110.1, C111.1, R104.1, U102.126 (VCCPLL1)
unnamed: D101.3, U102.108 (VPP_2V5)
unnamed: C301.1, R328.1, U301.3 (+)
unnamed: C302.1, C307.1, U301.1, U301.2 (-)
unnamed: C303.1, R331.1, U301.5 (+)
unnamed: C304.1, C308.1, U301.6 (-), U301.7
unnamed: C305.1, C306.1, FB301.1, U301.8 (V+)
unnamed: R606.1, U601.62 (EECLK), U603.2 (SCLK)
unnamed: R605.1, U601.63 (EECS), U603.1 (CS)
unnamed: R603.2, U601.61 (EEDATA), U603.3 (DI)
unnamed: C615.1, U601.2 (OSCI), Y601.1
unnamed: C616.1, U601.3 (OSCO), Y601.3
unnamed: R601.2, U601.6 (REF)
unnamed: C612.1, C613.1, FB602.2, U601.4 (VPHY)
unnamed: C610.1, C611.1, FB601.2, U601.9 (VPLL)
unnamed: R603.1, R604.1, U603.4 (DO)
unnamed: C702.1, U701.1 (BST)
unnamed: C706.1, U701.6 (COMP)
unnamed: R706.1, U701.7 (EN)
unnamed: R704.1, R705.2, U701.5 (FB)
unnamed: C707.1, U701.8 (SS)
unnamed: C702.2, L701.1, U701.3 (SW)
unnamed: R101.2, X101.3 (OUT)

File kicad/m1s-fpga-playground/production/fpga-board-bom.xlsx (part):

Source: | /home/mctom/git/m1s-fpga-addon/m1s-fpga-addon.kicad_sch
Date: | Wed 29 Nov 2023 22:18:25 CET
Tool: | Eeschema 7.0.9
Generator: | /usr/share/kicad/plugins/bom_csv_grouped_by_value.py
Component Count: | 188
Collated Components:
Item | Qty | Reference(s) | Value | LibPart | Footprint | Mouser PN | TME PN | Remarks | Datasheet | DNP | Alt | Description | LCSC
1 | 39 | C101, C102, C103, C104, C105, C106, C107, C108, C110, C112, C113, C114, C115, C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 | 100n | Device:C_Small | Capacitor_SMD:C_0603_1608Metric |  |  | mounted | ~ |  |  |  | C14663
2 | 5 | C109, C111, C306, C307, C308 | 10u | Device:C_Small | Capacitor_SMD:C_0603_1608Metric |  |  | mounted | ~ |  |  |  | C96446
3 | 2 | C125, C126 | 10n | Device:C_Small | Capacitor_SMD:C_0603_1608Metric |  |  | mounted | ~ |  |  |  | C57112
4 | 4 | C301, C303, C615, C616 | 30p | Device:C_Small | Capacitor_SMD:C_0603_1608Metric |  |  | mounted | ~ |  |  |  | C1658
5 | 2 | C302, C304 | 10p | Device:C_Small | Capacitor_SMD:C_0603_1608Metric |  |  | mounted | ~ |  |  |  | C1634
6 | 3 | C602, C610, C612 | 4u7 | Device:C_Small | Capacitor_SMD:C_0603_1608Metric |  |  | mounted | ~ |  |  |  | C19666
7 | 1 | C702 | 10n 16V | Device:C_Small | Capacitor_SMD:C_0603_1608Metric |  |  | mounted | ~ |  |  |  | C57112
8 | 3 | C704, C705, C708 | 22u 35V | Device:C | Capacitor_SMD:C_1206_3216Metric | 187-CL31A226KAHNNNE |  |  | ~
9 | 1 | C706 | 6n8 | Device:C_Small | Capacitor_SMD:C_0603_1608Metric |  |  | mounted | ~
10 | 1 | D101 | BAT54S | Diode:BAT54S | Package_TO_SOT_SMD:SOT-23 |  |  | Have them | https://www.diodes.com/assets/Datasheets/ds11005.pdf |  | BAT54, BAT54C
11 | 1 | D102 | Green | Device:LED_Small | LED_SMD:LED_0603_1608Metric |  |  | mounted | ~ |  |  |  | C72043
12 | 1 | D108 | BAT54A | Diode:BAT54A | Package_TO_SOT_SMD:SOT-23 |  |  | Have them | http://www.diodes.com/_files/datasheets/ds11005.pdf
13 | 7 | D217, D218, D219, D220, D221, D222, D223 | G | Device:LED_Small | LED_SMD:LED_0603_1608Metric |  |  | mounted | ~ |  |  |  | C72043
14 | 4 | FB301, FB302, FB601, FB602 | FerriteBead_Small | Device:FerriteBead_Small | Capacitor_SMD:C_0603_1608Metric |  |  | mounted | ~ |  |  |  | C1002
15 | 4 | H1, H2, H3, H4 | M3 | Mechanical:MountingHole_Pad | MountingHole:MountingHole_3.2mm_M3_DIN965_Pad |  |  | N/A | ~
16 | 1 | J1 | Conn_02x20_Odd_Even | Connector_Generic:Conn_02x20_Odd_Even | Connector_PinSocket_2.54mm:PinSocket_2x20_P2.54mm_Vertical |  | ZL262-40DG |  | ~
17 | 1 | J2 | Conn_02x07_Odd_Even | Connector_Generic:Conn_02x07_Odd_Even | Connector_PinSocket_2.54mm:PinSocket_2x07_P2.54mm_Vertical |  | ZL262-14DG |  | ~
18 | 1 | J102 | Pin Header | Connector_Generic:Conn_01x04 | Connector_PinHeader_2.54mm:PinHeader_1x04_P2.54mm_Vertical |  |  | NM | ~
19 | 1 | J301 | ICD15S13E4GX00LF | Connector:DE15_Receptacle_HighDensity_MountingHoles | libs:ICD15S13E4GX00LF | 649-ICD15S13E4GX00LF | ICD15S13E4GX00LF |  | ~
20 | 1 | J302 | CUI_SJ1-3533NG | Connector_Audio:AudioJack3 | Connector_Audio:Jack_3.5mm_CUI_SJ1-3533NG_Horizontal | 490-SJ1-3533NG |  |  | ~
21 | 1 | J501 | 10029449-101RLF | Connector:HDMI_A | Connector_HDMI:HDMI_A_Amphenol_10029449-x01xLF_Horizontal | 649-10029449-101RLF | 10029449-001RLF | A bit different across shops | https://en.wikipedia.org/wiki/HDMI
22 | 1 | J702 | CUI PJ102 | Connector:Barrel_Jack_Switch | Connector_BarrelJack:BarrelJack_CUI_PJ-102AH_Horizontal | 490-PJ-102AH |  |  | ~
23 | 1 | J703 | 5.08mm | Connector:Screw_Terminal_01x02 | TerminalBlock_Phoenix:TerminalBlock_Phoenix_MKDS-3-2-5.08_1x02_P5.08mm_Horizont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 |  | EB21A-02-D |  | ~
24 | 1 | L701 | SRN8040-100M | Device:L | Inductor_SMD:L_Bourns-SRN8040_8x8.15mm |  |  | Have them | ~ |  |  | 10u 3.1A 50mR
25 | 1 | LOGO101 | Logo_Open_Hardware_Small | Graphic:Logo_Open_Hardware_Small | Symbol:OSHW-Logo_7.5x8mm_SilkScreen |  |  | N/A | ~
26 | 3 | Q501, Q502, Q503 | 2N7002 | Transistor_FET:2N7002 | Package_TO_SOT_SMD:SOT-23 |  |  | mounted | https://www.onsemi.com/pub/Collateral/NDS7002A-D.PDF
27 | 1 | Q701 | PMT21EN | Device:Q_NMOS_GDSD | Package_TO_SOT_SMD:SOT-223 |  |  | Have them | https://www.mouser.pl/datasheet/2/916/PMT21EN-3083611.pdf
28 | 1 | R101 | 22R | Device:R_Small | Resistor_SMD:R_0603_1608Metric |  |  | mounted | ~ |  |  |  | C23345
29 | 10 | R102, R105, R107, R108, R109, R332, R333, R604, R605, R606 | 10k | Device:R_Small | Resistor_SMD:R_0603_1608Metric |  |  | mounted | ~ |  |  |  | C25804
30 | 2 | R103, R104 | 100R | Device:R_Small | Resistor_SMD:R_0603_1608Metric |  |  | mounted | ~ |  |  |  | C22775
31 | 8 | R110, R217, R218, R219, R220, R221, R222, R223 | 2k2 | Device:R_Small | Resistor_SMD:R_0603_1608Metric |  |  | mounted | ~ |  |  |  | C4190
32 | 9 | R301, R302, R303, R310, R311, R312, R319, R320, R321 | 1k 0.1% | Device:R_Small | Resistor_SMD:R_0603_1608Metric |  |  | mounted | ~ |  |  |  | C21190
33 | 9 | R304, R305, R306, R313, R314, R315, R322, R323, R324 | 2k 0.1% | Device:R_Small | Resistor_SMD:R_0603_1608Metric |  |  | mounted | ~ |  |  |  | C22975
34 | 7 | R307, R308, R316, R317, R318, R325, R326 | 16k 0.1% | Device:R_Small | Resistor_SMD:R_0603_1608Metric |  |  | Have them | ~
35 | 2 | R309, R327 | 120R | Device:R_Small | Resistor_SMD:R_0603_1608Metric |  |  | mounted | ~ |  |  |  | C22787
36 | 4 | R328, R329, R330, R331 | 47k | Device:R_Small | Resistor_SMD:R_0603_1608Metric |  |  | mounted | ~ |  |  |  | C25819
37 | 4 | R501, R502, R503, R504 | NM | Device:R_Small | Resistor_SMD:R_0603_1608Metric |  |  | TBD | ~
38 | 8 | R505, R506, R507, R508, R509, R510, R511, R512 | 0 | Device:R_Small | Resistor_SMD:R_0603_1608Metric |  |  | TBD | ~
39 | 3 | R513, R515, R517 | 4k7 | Device:R_Small | Resistor_SMD:R_0603_1608Metric |  |  | mounted | ~ |  |  |  | C23162
40 | 3 | R514, R516, R518 | 1k5 | Device:R_Small | Resistor_SMD:R_0603_1608Metric |  |  | mounted | ~ |  |  |  | C22843
41 | 1 | R519 | 51R | Device:R_Small | Resistor_SMD:R_0603_1608Metric |  |  | mounted | ~ |  |  |  | C23197
42 | 2 | R520, R602 | 1k | Device:R_Small | Resistor_SMD:R_0603_1608Metric |  |  | mounted | ~ |  |  |  | C21190
43 | 3 | R521, R701, R706 | 100k | Device:R_Small | Resistor_SMD:R_0603_1608Metric |  |  | mounted | ~ |  |  |  | C25803
44 | 1 | R601 | 12k | Device:R_Small | Resistor_SMD:R_0603_1608Metric |  |  | mounted | ~ |  |  |  | C22790
45 | 1 | R603 | 2k | Device:R_Small | Resistor_SMD:R_0603_1608Metric |  |  | mounted | ~ |  |  |  | C22975
46 | 1 | R703 | 6k8 | Device:R_Small | Resistor_SMD:R_0603_1608Metric |  |  | mounted | ~ |  |  |  | C23212
47 | 1 | R704 | 33k | Device:R_Small | Resistor_SMD:R_0603_1608Metric |  |  | mounted | ~ |  |  |  | C4216
48 | 1 | R705 | 7k5 | Device:R_Small | Resistor_SMD:R_0603_1608Metric |  |  | mounted | ~ |  |  |  | C23234
49 | 5 | SW101, SW102, SW103, SW104, SW105 | KMR2 | Switch:SW_Push | Button_Switch_SMD:SW_Push_1P1T_NO_CK_KMR2 | 611-KMR211NGLFS |  |  | ~
50 | 1 | U101 | W25Q16JLSSIG | Memory_Flash:W25Q32JVSS | Package_SO:SOIC-8_5.23x5.23mm_P1.27mm | 454-W25Q16JLSNIG |  | Slightly narrower package | http://www.winbond.com/resource-files/w25q32jv%20revg%200327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
51 | 1 | U102 | ICE40HX4K-TQ144 | FPGA_Lattice:ICE40HX4K-TQ144 | Package_QFP:TQFP-144_20x20mm_P0.5mm | 842-ICE40HX4K-TQ144 |  |  | http://www.latticesemi.com/Products/FPGAandCPLD/iCE40
52 | 1 | U103 | TLV71312PDBV | Regulator_Linear:TLV71312PDBV | Package_TO_SOT_SMD:SOT-23-5 |  |  | Have them | http://www.ti.com/lit/ds/symlink/tlv713p.pdf
53 | 1 | U106 | AS4C32M8SA | Memory_RAM:AS4C4M16SA | Package_SO:TSOP-II-54_22.2x10.16mm_P0.8mm | 155-A3V56S30GTP-60 |  |  | https://www.mouser.pl/datasheet/2/12/AllianceMemory_256M_AS4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
54 | 1 | U301 | OPA1602 | Amplifier_Operational:OPA1602 | Package_SO:SO-8_3.9x4.9mm_P1.27mm | 595-OPA1662AIDR |  | The original won't work at 3V3 | http://www.ti.com/lit/ds/symlink/opa1604.pdf
55 | 1 | U601 | FT2232HL | Interface_USB:FT2232HL | Package_QFP:LQFP-64_10x10mm_P0.5mm |  |  | Have them | https://www.ftdichip.com/Support/Documents/DataSheets/ICs/DS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

## Commit log

2023-12-02 Initial Commit - unit sent to production
2023-12-02 Relevant README
2023-12-02 Adding ice40_lib submodule
2023-12-02 ice40_lib update
2023-12-02 Blinky example (not tested)
2023-12-03 Swapped pins 128 and 129 - PLL conflict
2023-12-03 fix typo in comments
2023-12-04 Blinky: Adding clock constraints and optimization
2023-12-17 Updated makefile for M1S
2023-12-19 Added "reset" as makefile option
2023-12-19 updated ice40_lib
2023-12-22 640x480 demo working, picture slightly off the screen
2023-12-22 Working 1024x768
2023-12-22 lib update for vga.v
2023-12-22 vga.v - updated comments
2023-12-22 Sigh.. vga.v header
2023-12-23 vga_ddr: working at 1024x768
2023-12-23 1080p working! :O
2023-12-23 DDR VGA demo, finished
2023-12-29 Added grayscale conversion
2024-01-16 Added dithering to DDR VGA demo
2024-01-17 Dither algorithm changed to Blue Noise
2024-01-17 submodule update
2024-01-28 Improved dithering demo
2024-06-16 UART Loopback
2024-06-22 Updated lib
2024-06-22 New gateware examples
